# IAR project Backup of MIDO-ALMDDS-JST_v1_4.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 128
  General.SCRStackSize: 64
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-sf-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m168pa ATmega168PA
  ICCAVR.newCCIncludePaths: Source\drivers\min_driver\; Source\drivers\atmel_driver\; Source\; 
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 1
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm168pa.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.GenDeviceSelectMenu: 0 -v0, Max 256 byte data, 8 Kbyte code
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\lnk0t.xcl
  group Source
    Source/: adc.c alarm.c fnd_display.c main.c module_initialize.c motor.c ps-33d.c switch.c system_mode.c usart.c
  group Source/drivers/atmel_driver
    Source/drivers/atmel_driver/: avr_gpio_driver.c avr_twi_master_driver.c
  group Source/drivers/min_driver
    Source/drivers/min_driver/: type_conversion_util.c
